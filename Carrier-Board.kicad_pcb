# Repository LetSat/Carrier-Board

## KiCad design Carrier-Board.kicad_pcb

Parts:
C1, C3: 10uF; C_0805
C2, C4: 22uF; C_0805
C27, C28, C29: .1uF; C_0603
D5: D_Zener 9V; D_SOD-323
D6, D7, D8: LED; D_1206
G1: LOGO; LetSatLogo440
J1: CONN_3-6318491-6; ComExpressMini10
J2: Conn_01x0; Barrel_Jack_CUI_PJ-036AH-SMT
J3, J5: Conn_02x26_Odd_Even; ESQ-126-XX-X-D
J4: SI-51009-F; Manufacturer_Part_Number SI-51009-F
J6, J7: Conn_01x03_Male; Pin_Header_Angled_1x03_Pitch2.54mm
J8: Conn_01x06_Male; Pin_Header_Angled_1x06_Pitch2.54mm
J9: Conn_02x04_Odd_Even; Pin_Header_Angled_2x04_Pitch2.54mm
J10: Conn_02x03_Odd_Even; Pin_Header_Angled_2x03_Pitch2.54mm
R1, R5: 160k; R_0805
R2: 30.1k; R_0805
R3, R7: 100k; R_0805
R4: 63.4k; R_0805
R6: 51k; R_0805
R8: 56k; R_0805
R9, R10: 330; R_0805
R11, R12, R13: 10K; R_0603
R23: 330; R_0603
R24: 180; R_0603
R25: 1k; R_0603
R32: 0; R_0805
SW1, SW2, SW3: SW_Push; SW_SPST_B3U-1000P
U1, U2: MPM3620; QFN-20
U9: MSATA-Socket; mpcie-socket

Connections:
GBE0_CTREF(GND): C1.2, C2.2, C3.2, C4.2, C27.2, C28.2, C29.2, J1.1, J1.11, J1.14, J1.21, J1.31, J1.41, J1.51, J1.57, J1.60, J1.66, J1.70, J1.80, J1.90, J1.100, J1.110, J1.111, J1.121, J1.131, J1.141, J1.151, J1.161, J1.170, J1.180, J1.190, J1.200, J1.210, J1.220, J1.223, J1.224, J2.2, J2.3, J4.1, J4.6, J4.17, J4.18, J6.1, J7.1, J8.6, J10.6, R9.1, R10.1, R23.1, R24.1, R25.1, R32.2, SW1.1, SW2.1, SW3.1, U1.12 (PGND), U1.13 (PGND), U1.14 (PGND), U2.12 (PGND), U2.13 (PGND), U2.14 (PGND), U9.4 (GND), U9.9 (GND), U9.15 (GND), U9.18 (GND), U9.21 (GND), U9.26 (GND), U9.27 (GND), U9.29 (GND), U9.34 (GND), U9.35 (GND), U9.37 (GND), U9.40 (GND), U9.50 (GND)
GBE0_LINK100#: J1.4, J4.16
GBE0_LINK1000#: J1.5, J4.13
GBE0_MDI0+: J1.13, J4.2
GBE0_MDI0-: J1.12, J4.3
GBE0_MDI1+: J1.10, J4.4
GBE0_MDI1-: J1.9, J4.5
GBE0_MDI2+: J1.7, J4.7
GBE0_MDI2-: J1.6, J4.8
GBE0_MDI3+: J1.3, J4.9
GBE0_MDI3-: J1.2, J4.10
GNDA: R2.2, R4.2, R6.2, R8.2, U1.3 (AGND), U2.3 (AGND)
GPI0: J1.54, J9.1
GPI1: J1.63, J9.3
GPI2: J1.67, J9.5
GPI3: J1.85, J9.7
GPO0: J1.93, J9.2
GPO1: J1.164, J9.4
GPO2: J1.167, J9.6
GPO3: J1.173, J9.8
I2C_CK: J1.143, J6.3
I2C_DAT: J1.144, J6.2
unnamed: D5.2 (A), D6.2 (A)
unnamed: D6.1 (K), R24.2
unnamed: D7.1 (K), R23.2
unnamed: D8.1 (K), R25.2
unnamed: J4.14, R10.2
unnamed: J4.15, R9.2
unnamed: R1.2, R2.1, U1.1 (FB)
unnamed: R3.2, U1.17 (EN)
unnamed: R4.1, U1.18 (AAM)
unnamed: R5.2, R6.1, U2.1 (FB)
unnamed: R7.2, U2.17 (EN)
unnamed: R8.1, U2.18 (AAM)
unnamed: R32.1, U9.51 (Pres._Det.)
PWRBTNn: J1.122, J8.5, R11.1, SW1.2
PWR_OK: J1.134, J8.2
SATA0_RX+: J1.19, U9.23 (+B)
SATA0_RX-: J1.20, U9.25 (-B)
SATA0_TX+: J1.16, U9.33 (+A)
SATA0_TX-: J1.17, U9.31 (-A)
SATA_ACTn: J1.28, U9.49 (DA/DSS)
SLEEPn: J1.213, J8.1
SPI_CLK: J1.94, J10.3
SPI_CS#: J1.97, J10.5
SPI_MISO: J1.92, J10.1
SPI_MOSI: J1.95, J10.4
SYS_RESETn: J1.159, J8.4, R12.2, SW2.2
WAKE1n: J1.177, J8.3, R13.2, SW3.2
mCOM_5V_SBY: C2.1, D8.2 (A), J1.194, J1.195, J1.196, J1.197, R1.1, R11.2, R12.1, R13.1, U1.7 (OUT), U1.8 (OUT), U1.9 (OUT)
mCOM_12V: C1.1, C3.1, D5.1 (K), J1.104, J1.105, J1.106, J1.107, J1.108, J1.109, J1.214, J1.215, J1.216, J1.217, J1.218, J1.219, J2.1, R3.1, R7.1, U1.16 (IN), U2.16 (IN)
mCOM_RX: J1.99, J7.2
mCOM_TX: J1.98, J7.3

Notes on the sheet:
Break out
LED Indicators
3V3
12V
5V SBY
Voltage Supply
LetSat-1 Carrier Prototype
Spring 2018
Sata Connector
Ethernet
mCOMTK1
I2C
Rs232
SPI
GPIO
MISC SHIT
PC104
Pixie Wranglers: Prabodh Jhaveri Chandler Griscom

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
Board: 4 copper layers, 92.0 x 96.0 mm, 49 parts (10 on the bottom side), 54 nets.

Other parts of the board:
G1#2: LOGO; LetSatLogo440
m1, m1#2, m2: MountingHole_2.7mm_M2.5_Pad

## Commit log

2017-12-14 Skeleton
2017-12-14 Import some old footprints and logo
2017-12-14 Add converted PC104-plus connector from eagle libs
2018-01-20 Add better pc104 footprint
2018-01-26 Misc footprint stuff and ethernet
2018-01-26 Remove junk from pc104
2018-01-27 Add 26x2 connector for pc104
2018-01-27 'kidz
2018-01-27 Add old schematic
2018-01-27 added footprints
2018-01-27 schematic 90% done
2018-01-27 began layot
    added dc jack, fixed ethernet footptrint aligned pc104
2018-01-28 Finished Schmatic
    Didnt do pc104 connector
2018-01-28 Added SPI
    Added SPI
    Added GPIO
    Fixed 12V
2018-01-28 Notes
2018-01-28 added buttons
2018-01-28 Change but3ton footprint
2018-01-28 started traces
2018-01-31 added more traces
    Sata finished
    i2c ansd misc shit done
    need:
    gpio
    spi
    ethernet
2018-02-01 4 layer switch
    changed to 4 layer
2018-02-02 ethernet
2018-02-02 Finished Traces
    No camera
    needs verification
2018-02-03 added mounting holes
2018-02-05 CHANGED MMOUNTING HOLES FOR STANDOFFF
2018-02-08 Fix DRC and unconnected tracks
2018-02-11 asdasdasdasd
2018-02-11 no shorts i think
2018-02-11 fixed a connector
    connector too close to edge.
2018-02-11 Fix some DRC errors
2018-02-13 final rev to send
2018-02-27 added bom
2018-09-05 Increased trace size, fixed 5v rail
2018-09-14 Fixed Schema Issues

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
